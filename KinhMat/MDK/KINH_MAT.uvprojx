# Keil uVision project KINH_MAT.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00004000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: VL53L0X +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F030X6
  c include: ..\LIB\user;..\LIB\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\LIB\Libraries\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Libraries cmsis
    ../LIB/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_flash.c stm32f0xx_dma.c
  group Source
    ../Source/: main.c
  group User
    ../Source/: i2c.c delay.c timer.c adc.c vl53l0x.c uart.c flash.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
